SRCREV="d2797fb183531df875fbbaa17523362a09c90bda"
SRC_URI="git://github.com/Numb-66/hailo-u-boot.git;protocol=https;branch=1.7.1"
